<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>libs</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\libs\clock_led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\libs\clock_led.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\libs\commonTypes.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\libs\nRF.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\libs\nRF.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\libs\nRF_IRQ_stm8x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\libs\nRF_IRQ_stm8x.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\libs\nRF_RegText.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\libs\nRF_RegText.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\libs\nRF_SPI.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\libs\nRF_SPI.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\libs\nRF_Tx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\libs\nRF_Tx.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\libs\rx_protocol.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\libs\rx_protocol.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\libs\spi_stm8x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\libs\spi_stm8x.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\libs\temp_ds18b20.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\libs\temp_ds18b20.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\libs\uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\libs\uart.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\libs\uart_stm8x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\libs\uart_stm8x.h</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\deviceType.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\nRF_Configuration.h</name>
  </file>
</project>


