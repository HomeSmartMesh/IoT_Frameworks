<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\rf_bridge\rf_bridge.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\rf_emulator\rf_emulator.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\rf_receiver_logger\rf_receiver_logger.ewp</path>
  </project>
  <batchBuild/>
</workspace>


