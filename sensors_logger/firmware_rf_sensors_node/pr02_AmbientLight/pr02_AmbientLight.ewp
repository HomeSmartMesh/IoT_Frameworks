# IAR project pr02_AmbientLight.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151F3 STM8L151F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; ..\..\..\libs
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: pr02_AmbientLight.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: deviceType.h main.c nRF_Configuration.h
  group libs
    ../../../libs/: clock_led.c clock_led.h commonTypes.h i2c_stm8x.c i2c_stm8x.h nRF_IRQ.c nRF_IRQ.h nRF_Modes.c nRF_Modes.h nRF_RegText.c nRF_RegText.h nRF_SPI.c nRF_SPI.h nRF_Tx.c nRF_Tx.h spi_stm8x.c spi_stm8x.h uart.c uart.h uart_stm8x.c uart_stm8x.h
