# IAR project rf_p2p_tester.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; ..\..\libs
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: rf_p2p_tester.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: deviceType.h main_rfp2p.c nRF_Configuration.h uart_config.h
  group libs
    ../../libs/: clock_led.c clock_led.h cmdutils.c cmdutils.h commonTypes.h nRF.c nRF.h nRF_IRQ_stm8x.c nRF_IRQ_stm8x.h nRF_P2P.c nRF_P2P.h nRF_RegText.c nRF_RegText.h nRF_SPI.c nRF_SPI.h nRF_Tx.c nRF_Tx.h rf_protocol.c rf_protocol.h spi_stm8x.c spi_stm8x.h uart.c uart.h uart_stm8x.c uart_stm8x.h
