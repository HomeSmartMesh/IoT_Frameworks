<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\rf_p2p_tester\rf_p2p_tester.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\rf_tester\rf_tester.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\rfmaster\rfmaster.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\uarttester\uarttester.ewp</path>
  </project>
  <batchBuild/>
</workspace>


