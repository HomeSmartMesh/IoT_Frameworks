<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\dimmer_solo\dimmer_solo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\simple_monitor\simple_monitor.ewp</path>
  </project>
  <batchBuild/>
</workspace>


