<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Firmware_STM8_IoTNode\Firmware_STM8_IoTNode.ewp</path>
  </project>
  <batchBuild/>
</workspace>


