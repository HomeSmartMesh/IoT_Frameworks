<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\rfmaster\rfmaster.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\uarttester\uarttester.ewp</path>
  </project>
  <batchBuild/>
</workspace>


