<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>pr00_LibraryCommon</name>
    <file>
      <name>$PROJ_DIR$\..\pr00_LibraryCommon\ClockUartLed.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\pr00_LibraryCommon\ClockUartLed.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\pr00_LibraryCommon\commonTypes.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\pr00_LibraryCommon\nRF_IRQ.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\pr00_LibraryCommon\nRF_IRQ.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\pr00_LibraryCommon\nRF_LowLevel.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\pr00_LibraryCommon\nRF_LowLevel.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\pr00_LibraryCommon\nRF_Modes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\pr00_LibraryCommon\nRF_Modes.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\pr00_LibraryCommon\nRF_RegText.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\pr00_LibraryCommon\nRF_RegText.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\pr00_LibraryCommon\nRF_SPI.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\pr00_LibraryCommon\nRF_SPI.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\pr00_LibraryCommon\nRF_Tx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\pr00_LibraryCommon\nRF_Tx.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\pr00_LibraryCommon\temp_ds18b20.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\pr00_LibraryCommon\temp_ds18b20.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\pr00_LibraryCommon\WS2812B.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\pr00_LibraryCommon\WS2812B.h</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\nRF_Configuration.h</name>
  </file>
</project>


