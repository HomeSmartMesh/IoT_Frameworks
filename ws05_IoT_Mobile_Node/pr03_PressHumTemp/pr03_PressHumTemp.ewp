# IAR project pr03_PressHumTemp.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151F3 STM8L151F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; ..\pr00_LibraryCommon
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: pr03_PressHumTemp.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: BMP280_API.c BMP280_API.h i2c_m.c i2c_m.h main.c nRF_Configuration.h
  group pr00_LibraryCommon
    ../pr00_LibraryCommon/: ClockUartLed.c ClockUartLed.h commonTypes.h nRF_IRQ.c nRF_IRQ.h nRF_LowLevel.c nRF_LowLevel.h nRF_Modes.c nRF_Modes.h nRF_RegText.c nRF_RegText.h nRF_SPI.c nRF_SPI.h nRF_Tx.c nRF_Tx.h temp_ds18b20.c temp_ds18b20.h WS2812B.c WS2812B.h
