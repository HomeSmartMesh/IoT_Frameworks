<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <file>
    <name>$PROJ_DIR$\BMP280_API.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\BMP280_API.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\i2c_m.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\i2c_m.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\nRF_Configuration.h</name>
  </file>
</project>


