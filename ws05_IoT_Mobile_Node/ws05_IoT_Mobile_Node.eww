<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\pr01_Node_Alive\pr01_Node_Alive.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pr02_AmbientLight\pr02_AmbientLight.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pr03_PressHumTemp\pr03_PressHumTemp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pr04_LightBroadcast\pr04_LightBroadcast.ewp</path>
  </project>
  <batchBuild/>
</workspace>


