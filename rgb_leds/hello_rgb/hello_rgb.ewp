# IAR project hello_rgb.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; ..\..\libs
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: hello_rgb.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: deviceType.h mainRGB.c rgb_config.h uart_config.h
  group libs
    ../../libs/: clock_led.c clock_led.h commonTypes.h uart.c uart.h uart_stm8x.c uart_stm8x.h WS2812B.c WS2812B.h
